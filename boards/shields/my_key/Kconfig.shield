## boards/shields/my_key/Kconfig.shield
```kconfig
# No whitespace after the comma or in the keyboard name!
config SHIELD_MY_KEY
    def_bool $(shields_list_contains,my_key)
```
